# Keil uVision project InductionCooker.uvproj, settings and files
target IH (MCS-51)
  device: SN8F5602 DataVersion
  cpu: IRAM(0-0xFF) XRAM(0-0x02FF) IROM(0-0x47F5) CLOCK(32000000) MODC2 DPC
  output: IH +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51 main.c OPTIONS_SN8F5602.A51 TRIM_INFO_SN8F5602.A51 ADC.c power.c temperature.c timer0.c timer1.c timer2.c system.c comparator.c OP_amp.c gpio.c communication.c PWM.c buzzer.c I2C.c
